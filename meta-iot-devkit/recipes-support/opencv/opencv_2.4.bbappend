PACKAGECONFIG ??= "eigen jpeg png tiff v4l"
